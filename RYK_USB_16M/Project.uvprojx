# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --bincombined --bincombined_padding=1,0xff --output outfile.bin  !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,USE_USB_OTG_FS
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\FATFS;.\USB\USB_APP;.\USB\STM32_USB_OTG_Driver\inc;.\USB\STM32_USB_Device_Library\Core\inc;.\USB\STM32_USB_Device_Library\Class\msc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_cl.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h usart.c usart.h
  group Hardware
    ./Hardware/: LED.c LED.h MySPI.c MySPI.h 4G.c 4G.h protocol_def.h protocol_handler.c RS485.c RS485.h WindSpeed.c WindSpeed.h Weather.c Weather.h WindDirection.c WindDirection.h rtc.c rtc.h 24LC64F.c 24LC64F.h W25Q128.c W25Q128.h W25Q128_Ins.h ATCMD_config.c ATCMD_config.h Rainfall.c Rainfall.h MIC29302.c MIC29302.h Power_test.c Power_test.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Fatfs
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c FATapp.c FATapp.h
  group USB_OTG
    ./USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_scsi.c
  group USB_DEVICE
    ./USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c
  group USB_APP
    ./USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
